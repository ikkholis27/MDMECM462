# Keil uVision project mcu_l716p.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: GD32F303CE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mcu_l716p +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER GD32F30X_HD
  c include: .\lib\GD32F30x_standard_peripheral\Include;.\lib\CMSIS\GD\GD32F30x\Include;.\lib\CMSIS;.\app
  asm include: .\lib\CMSIS\GD\GD32F30x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sartup
    ./lib/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group CMSIS
    ./lib/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Lib
    ./lib/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_usart.c gd32f30x_rcu.c
    ../MCU_L716P_modeAV1.1/lib/GD32F30x_standard_peripheral/Source/: gd32f30x_timer.c gd32f30x_fmc.c gd32f30x_exti.c gd32f30x_fwdgt.c
  group App
    ./app/: gd32f30x_it.c usart.c main.c
